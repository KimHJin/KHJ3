# IAR project NON-CONTACT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: NON-CONTACT.bin
  ILINK.IlinkOutputFile: NON-CONTACT.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: eeprom.c IWON_SCAN.cpp IWON_TASK.cpp IWON_VAVG.cpp lcd_drive.c main.cpp stm8l15x_adc.c stm8l15x_clk.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_tim4.c
